Commit message: 仅仅保留强化状态去掉手写动作

File: src/rl_sar_zoo/atdog2_description/urdf/dog2.urdf (robot description, URDF)
Before this commit: robot dog2, 18 links, 17 joints
Links:
- link base: mass 5.236 -> 4.510
